# Keil uVision project Project.uvproj, settings and files
target Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UN623_MH2020C_App_V2.x.x_release_20yymmdd.axf +hex
  AfterMake: fromelf --bin ".\Debug\obj\@L.axf" --output ".\Debug\obj\@L.bin"
  c flags: Optim=3
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: Libraries\Device\MegaHunt\mhscpu\Include;Libraries\CMSIS\Include;Libraries\MHSCPU_Driver\inc;User;.\Uart;.\pinpad;.\SPI;.\timer;.\User;.\1608c;.\flash
  library: MicroLIB
  memory RVCT4: ROM 0x1010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    User/: main.c
    ./Libraries/MHSCPU_Driver/src/: mhscpu_it.c
    ./User/: function_test.c
  group MDK-ARM
    Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    Libraries/MHSCPU_Driver/src/: misc.c mhscpu_uart.c mhscpu_gpio.c mhscpu_sysctrl.c
    ./Libraries/MHSCPU_Driver/src/: mhscpu_spi.c mhscpu_timer.c mhscpu_cache.c mhscpu_qspi.c mhscpu_dma.c mhscpu_exti.c
  group CMSIS
    Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group Uart
    ./Uart/: uart.c
  group spi
    ./spi/: spi.c
  group pinpad
    ./pinpad/: commandpro.c picc_api.c
  group system
    ./system/: system.c
  group timer
    ./timer/: timer.c
  group MH1608C
    ./1608c/: iso14443_4.c iso14443a.c iso14443b.c mh523.c mhtest.c mifare.c rfid.c typeb.c
  group flash
    ./flash/: flash.c
